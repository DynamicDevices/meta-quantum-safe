require liboqs.inc

ORG="open-quantum-safe"
BRANCH="0.10.1-release"
SRCREV = "5dd87dcaafa6f90e983ef464f9f6a75f9485fb26"

LIC_FILES_CHKSUM = " \
    file://LICENSE.txt;md5=4b93ef2da47496727a4e8a59f443844e \
    file://src/kem/bike/additional_r4/LICENSE;md5=34400b68072d710fecd0a2940a0d1658 \
    file://src/kem/kyber/pqcrystals-kyber_kyber512_ref/LICENSE;md5=011166b0c98b6730cf581065b9a9f069 \
"

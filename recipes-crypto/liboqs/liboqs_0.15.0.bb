require liboqs.inc

ORG="open-quantum-safe"
# Upstream 0.15.0 is tagged on main (no standard 0.15.0-release branch)
BRANCH="main"
SRCREV = "97f6b86b1b6d109cfd43cf276ae39c2e776aed80"

